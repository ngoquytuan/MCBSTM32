# Keil uVision project MCBSTM32.uvprojx, settings and files
target MCBSTM32 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mcbstm32 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\USER\delay;..\USER\uart;..\USER\rtc;..\USER\eeprom;..\USER\filter;..\USER\adcdma;..\USER\it;..\USER\lcd16x2;..\USER\crc16;..\USER\tim;..\USER\i2c;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ../USER/: MCBSTM32_main.c MCBSTM32_fuc.c
  group delay
    ../USER/delay/: delay.c
  group lcd
    ../USER/lcd16x2/: lcd16x2.c
  group uart
    ../USER/uart/: uart.c
  group interupt
    ../USER/it/: stm32f10x_it.c
  group rtc
    ../USER/rtc/: rtc.c
  group eeprom
    ../USER/eeprom/: eeprom_stm.c
  group kfilter
    ../USER/filter/: SimpleKalmanFilter.c
  group adcdma
    ../USER/adcdma/: adcdma.c
  group crc16
    ../USER/crc16/: crc16.c modbus_slave.c modbus_appphy.c
  group tim
    ../USER/tim/: tim.c
  group i2c
    ../USER/i2c/: i2c.c 24C32.c ads1015.c
software components: CMSIS:CORE 5.0.0, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:CEC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
